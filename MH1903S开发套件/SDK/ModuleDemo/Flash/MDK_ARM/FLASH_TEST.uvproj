# Keil uVision project FLASH_TEST.uvproj, settings and files
target RAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4
  c include: ..\User;..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\Libraries\MHSCPU_Driver\inc\cryptlib;..\..\..\Libraries\MHSCPU_Driver\inc\emvlib;..\..\..\EMV_Lib\User\emv_lib
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK_ARM
    ../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group USER
    ../User/: main.c mhscpu_it.c
  group CMSIS
    ../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group MHSCPU_Driver
    ../../../Libraries/MHSCPU_Driver/src/: mhscpu_cache.c mhscpu_dma.c mhscpu_gpio.c mhscpu_qspi.c mhscpu_sysctrl.c mhscpu_uart.c
