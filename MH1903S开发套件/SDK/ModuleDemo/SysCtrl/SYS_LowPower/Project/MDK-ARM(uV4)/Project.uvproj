# Keil uVision project Project.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c mhscpu_it.c
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_gpio.c mhscpu_exti.c mhscpu_rtc.c mhscpu_sensor.c mhscpu_timer.c mhscpu_qspi.c mhscpu_dma.c mhscpu_adc.c mhscpu_dac.c
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
