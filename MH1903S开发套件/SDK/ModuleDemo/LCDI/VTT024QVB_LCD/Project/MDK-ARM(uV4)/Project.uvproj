# Keil uVision project Project.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: VTT024QVB_LCD +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4
  c include: ..\..\User;..\..\..\..\..\Libraries\MHSCPU_Driver\src;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\MHSCPU_Driver\inc\cryptlib;..\..\..\..\..\Libraries\MHSCPU_Driver\inc\emvlib;..\..\..\..\..\EMV_Lib\User\emv_lib
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group User
    ../../User/: main.c ST7789V.c systick.c fonts.c picture.c
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_dma.c mhscpu_gpio.c mhscpu_lcdi.c mhscpu_sysctrl.c mhscpu_uart.c
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
