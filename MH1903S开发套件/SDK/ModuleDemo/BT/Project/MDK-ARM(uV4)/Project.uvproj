# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c misc: --c99 --gnu  --enum_is_int
  c include: ..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../User/: main.c bttest.c bt42_api.c bt42_uart.c bt42_v1.34.lib
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_uart.c mhscpu_timer.c mhscpu_gpio.c mhscpu_exti.c mhscpu_dma.c mhscpu_sysctrl.c
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
