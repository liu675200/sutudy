# Keil uVision project Project.uvproj, settings and files
target RAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\User;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\MHSCPU_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group User
    ../../User/: main.c wave_data.c
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_gpio.c mhscpu_dac.c mhscpu_dma.c
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
target Flash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CRC_Flash +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0xc000
  memory RVCT9: RAM 0x20010000 size 0x10000
