# Keil uVision project Musb_HID_Demo.uvproj, settings and files
target Musb_HID_Demo (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Musb_HID_Demo +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,HID_SUPPORT_IN_OUT
  c include: ..\user;..\user\inc;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Source\ARM;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Core\inc;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Class\hid\inc;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_OTG_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c usbd_desc.c usbd_usr.c mhscpu_it.c usb_bsp.c
  group Startup
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group Scpu_Peripheral_Lib
    ../../../../../Libraries/MHSCPU_Driver/src/: mhscpu_gpio.c misc.c mhscpu_sysctrl.c mhscpu_uart.c
  group SCPU_USB_OTG_DRIVER
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group SCPU_USB_Device_Library
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
