# Keil uVision project MSC_Device_Demo.uvproj, settings and files
target MSC_Device_Demo (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: MSC_Device_Demo +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\inc;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Source;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Source\ARM;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_OTG_Driver\inc;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Core\inc;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Class\msc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/: main.c mhscpu_it.c usb_bsp.c usbd_desc.c usbd_usr.c usbd_storage_msd.c
  group Startup
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group Scpu_Peripheral_lib
    ../../../../../Libraries/MHSCPU_Driver/src/: mhscpu_gpio.c mhscpu_uart.c misc.c mhscpu_sysctrl.c
  group SCPU_USB_CORE_DRIVER
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group SCPU_USB_Device_lib
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
