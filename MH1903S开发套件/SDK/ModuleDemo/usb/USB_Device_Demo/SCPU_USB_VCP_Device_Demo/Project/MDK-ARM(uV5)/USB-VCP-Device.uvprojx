# Keil uVision project USB-VCP-Device.uvprojx, settings and files
target USB-VCP-Device (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: USB-VCP-Device +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\APP\inc;..\..\BSP\inc;..\..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_OTG_Driver\inc;..\..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Core\inc;..\..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Class\cdc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../../APP/src/: App.c
  group BSP
    ../../BSP/inc/: mhscpu_conf.h usb_conf.h usbd_conf.h
    ../../BSP/src/: usb_bsp.c usbd_desc.c usbd_usr.c usbd_cdc_vcp.c USBBSP.c
  group Driver
    ../../../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_gpio.c mhscpu_uart.c mhscpu_spi.c mhscpu_wdt.c mhscpu_adc.c mhscpu_awd.c mhscpu_bpk.c mhscpu_cache.c mhscpu_crc.c mhscpu_dac.c mhscpu_dcmi.c mhscpu_dma.c mhscpu_driver.c mhscpu_emv_hard.c mhscpu_exti.c mhscpu_gpu.c mhscpu_i2c.c mhscpu_kcu.c mhscpu_lcdi.c mhscpu_otp.c mhscpu_qrcode.c mhscpu_qspi.c mhscpu_rtc.c mhscpu_sensor.c mhscpu_ssc.c mhscpu_timer.c mhscpu_trng.c mh_rand.c
    ../../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group Driver\USBDevice
    ../../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
software components: CMSIS:CORE 5.3.0
