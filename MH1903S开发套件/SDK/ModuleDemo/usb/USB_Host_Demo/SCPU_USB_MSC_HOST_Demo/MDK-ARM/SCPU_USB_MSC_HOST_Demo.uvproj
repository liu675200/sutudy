# Keil uVision project SCPU_USB_MSC_HOST_Demo.uvproj, settings and files
target SCPU_USB_MSC_HOST_Demo (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: SCPU_USB_MSC_HOST_Demo +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\inc;..\Third_Party\fat_fs\inc;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Source\ARM;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Source;..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_OTG_Driver\inc;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_HOST_Library\Core\inc;..\..\..\..\..\Libraries\SCPU_USB_Lib\SCPU_USB_HOST_Library\Class\MSC\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/: main.c mhscpu_it.c usb_bsp.c usbh_usr.c
  group Startup
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group Scpu_Peripheral_Lib
    ../../../../../Libraries/MHSCPU_Driver/src/: mhscpu_gpio.c mhscpu_uart.c misc.c mhscpu_sysctrl.c
  group SCPU_USB_OTG_DRIVER
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group SCPU_USB_Host_Library
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../../../../Libraries/SCPU_USB_Lib/SCPU_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FAT_FS
    ../Third_Party/fat_fs/src/: fattime.c ff.c
