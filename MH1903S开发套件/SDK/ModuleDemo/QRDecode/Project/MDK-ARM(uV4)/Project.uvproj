# Keil uVision project Project.uvproj, settings and files
target Flash (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Decode +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c misc: --enum_is_int --c99
  c include: ..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\User
  memory RVCT4: ROM 0x1001000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x100000
  group User
    ../../User/: main.c beep.c uart.c mhscpu_it.c DecodeDemo.c
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: mhscpu_dcmi.c mhscpu_uart.c misc.c mhscpu_dma.c mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_timer.c mhscpu_i2c.c
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group DecodeLib
    ../../../../Libraries/MHSCPU_Driver/lib/: MH1903S_QRDecode.lib
