# Keil uVision project ADC_Demo.uvproj, settings and files
target ADC_Demo (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: ADC_Demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\User;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\Libraries\MHSCPU_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
  group CMSIS
    ../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group MDK-ARM
    ../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../Libraries/MHSCPU_Driver/src/: mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_gpio.c mhscpu_adc.c
