# Keil uVision project project.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x80000
  memory RVCT9: RAM 0x20004000 size 0x10000
  group User
    ../User/: main.c image.c lcd.c timer.c
  group Driver
    ../../../../Libraries/MHSCPU_Driver/src/: mhscpu_gpio.c mhscpu_hspim.c mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_dma.c mhscpu_timer.c
  group Startup
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
