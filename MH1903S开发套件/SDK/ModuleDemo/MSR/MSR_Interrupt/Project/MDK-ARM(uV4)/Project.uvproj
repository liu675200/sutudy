# Keil uVision project Project.uvproj, settings and files
target RAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,RUN_IN_RAM
  c misc: --enum_is_int
  c include: ..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User;..\..\..\..\..\Libraries\MHSCPU_Driver\inc\securelib;..\..\..\..\..\Libraries\MHSCPU_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c mhscpu_it.c
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_timer.c
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group Lib
    ../../../../../Libraries/MHSCPU_Driver/lib/: MH1903S_MSR.lib
target RAM-JLINK (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
target Flash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User;..\..\..\Libraries\MHSCPU_Driver\inc\securelib;..\..\..\Libraries\MHSCPU_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x10000
