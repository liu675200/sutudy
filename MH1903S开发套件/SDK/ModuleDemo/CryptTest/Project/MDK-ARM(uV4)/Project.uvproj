# Keil uVision project Project.uvproj, settings and files
target Secure (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: crypt_s_Test +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c misc: --enum_is_int
  c include: ..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc\cryptlib;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User;..\..\User\cryptlibTest
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x12000
  group User
    ../../User/: main.c mhscpu_it.c
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_gpio.c mhscpu_timer.c mh_rand.c mhscpu_trng.c
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group CRYPT_SELF_TEST
    ../../user/cryptlibTest/: ecc_self_test.c aes_self_test.c debug.c des_self_test.c mh_bignum_tool.c rsa_self_test.c sha_self_test.c sm2_decryptencrypt_self_test.c sm2_digitalsign_self_test.c sm2_keyexchange_self_test.c sm3_self_test.c sm4_self_test.c
    ../../User/cryptlibTest/: ecdsa_digitalsign_self_test.c ecies_decryptencrypt_self_test.c
  group CRYPT_LIB
    ../../../../Libraries/MHSCPU_Driver/lib/: crypt_lib.lib
target Unsecure (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: cryptTest +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c misc: --enum_is_int
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x12000
  link misc: --callgraph
