# Keil uVision project MH1608C.uvproj, settings and files
target MH1608C_FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: MH1608C +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4
  c include: ..\User;..\User\1608c;..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\Libraries\MHSCPU_Driver\inc\cryptlib;..\..\..\Libraries\MHSCPU_Driver\inc\emvlib;..\..\..\EMV_Lib\User\emv_lib
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK_ARM
    ../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group CMSIS
    ../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group user
    ../User/: main.c gpio.c spi.c timer.c uart.c mhscpu_it.c
  group MHSCPU_Driver
    ../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_gpio.c mhscpu_spi.c mhscpu_sysctrl.c mhscpu_uart.c mhscpu_timer.c
  group 1608c
    ../User/1608c/: rfid.c iso14443_4.c iso14443a.c iso14443b.c mh523.c mifare.c
target MH1608C_SRAM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MH1608C +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\User;..\User\1608c;..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\Libraries\MHSCPU_Driver\inc;..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20004000 size 0x8000
  memory RVCT9: RAM 0x2000c000 size 0x8000
